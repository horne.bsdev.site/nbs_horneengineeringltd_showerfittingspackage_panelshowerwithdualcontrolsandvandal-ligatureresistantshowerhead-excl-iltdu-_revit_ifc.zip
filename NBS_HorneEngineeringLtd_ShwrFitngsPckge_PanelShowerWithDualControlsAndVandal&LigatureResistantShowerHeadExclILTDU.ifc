Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-11T07:59:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 11 07:59:26 2023 * Host: BIMServices * Database: C:\Users\PIOTRB~1\AppData\Local\Temp\f417ea85-6b6b-487b-86c9-a28277fa1a04\cab66bd5-6b77-4237-9ab8-e9d3863da9ea\ifc * Database version: 5507 * Database creation date: Wed Oct 11 07:59:26 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 11 07:59:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 11 07:59:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: TopEntryInletsStandardControlsT105A, NBS_HorneEngineeringLtd_ShwrFitngsPckge_PanelShowerWithDualControlsAndVandal&LigatureResistantShowerHeadExclILTDU:TopEntryInletsStandardControlsT105A:320780
In: Level 0
Type - PredefinedType: SHOWER; Material: NBS_HorneEngineeringLtd_Chrome, NBS_HorneEngineeringLtd_RAL9010
Type - BOS_General - Author: NBS; BIMObjectName: NBS_HorneEngineeringLtd_ShowerFittingsPackage_PanelShowerWithDualControlsAndVandalAndLigatureResistantShowerHeadExclILTDU_TopEntryInletsStandardControlsT105A; ManufacturerName: Horne Engineering Ltd; ManufacturerURL: www.horne.co.uk; ProductInformation: https://source.thenbs.com/product/-/56ed1c8a-e6da-4a89-88a8-13fb42d15cbd/83b08ad6-41c2-432c-9efa-43d6aa682375; Uniclass2015Title: Shower fittings package; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Version: Products v1.31; Version: 1
Type - NBS_Data - Accessories: Flushing kit, P/N 5138,465 mm Pipe cover kit, P/N SA-465PC,940 mm Pipe cover kit, P/N SA-940PC; Approvals: Type 3 and UK Water Regulation 4 Approved; Connections: Hot and cold, 15 mm compression fittings; CountryOfProductManufacture: United Kingdom; FlowRateMaximum: 8 L/min; Form: Wall-mounted shower panel with thermostatic mixer valve, hand controls and vandal resistant shower head; MaterialsBody: Shower panel: Aluminium extrusion; Shower valve: Brass; MaterialsFinishAndColour: Epoxy-polyester powder-coated white (RAL 9010) panel, chromium-plated shower head and hand controls; MixerValve: TSV1-3, with dual controls; Outlet: One head (single mode) - fixed, vandal and ligature resistant; Recyclability: Can be recycled; StandardsShowerMixers: To HTM Performance specification D 08; WaterPressure: Maximum static pressure: 10 bar. Range of maintained water supply pressures: 0.2–5 bar; WaterSupplyTemperatureMaximum: 41°C
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: Type 3 and UK Water Regulation 4 Approved (previously TMV3 Scheme and WRAS Approval respectively); Color: White; Constituents: n/a; Description: Surface mounted, pre-plumbed shower panels; DurationUnit: year; ExpectedLife: n/a; Features: Pressure and tested pre-plumbed assembly, integral Type 3 approved shower valve; Finish: Powder-coated; Grade: n/a; Manufacturer: specifications@horne.co.uk; Material: Aluminium,Brass,Copper,Zinc,Polymer,Plastic; ModelNumber: T105A; ModelReference: Single Mode Thermostatic Panel Shower With Dual Controls and Vandal and Ligature Resistant Shower Head (excl. ILTDU); Name: ShowerFittingsPackage_PanelShowerWithDualControlsAndVandalAndLigatureResistantShowerHeadExclILTDU_TopEntryInletsStandardControlsT105A_HorneEngineeringLtd; NominalHeight: 1015 mm; NominalLength: 0 mm; NominalWidth: 180 mm; ReplacementCost: n/a; Shape: Rectangle; Size: 180 x 130 x 1015 mm; SustainabilityPerformance: Integral 8 L/min flow regulator; WarrantyDescription: Two year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
